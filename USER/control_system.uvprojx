# Keil uVision project control_system.uvprojx, settings and files
target cy (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: control_system +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FATFS\exfuns;..\FATFS\src;..\FATFS\src\option;..\APP;..\AT;..\BSP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group BSP
    ../BSP/: delay.c sdio_sdcard.c sys.c usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_sdio.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c
    ../FATFS/src/option/: cc932.c syscall.c
